## main/Kconfig.projbuild
```kconfig
menu "AirPrint Bridge"
config BRIDGE_DIAG_NO_USB
    bool "Diagnostic mode: keep USB serial, skip host switch"
    default n
endmenu
```
